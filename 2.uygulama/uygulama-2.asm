	LIST P=16F877A
	#INCLUDE <P16F877A.INC>

	ORG 0X00
	GOTO ANA_METOT
	
ANA_METOT
	BANKSEL TRISB
	MOVLW 0XFF
	MOVWF TRISB
	MOVLW 0X00
	MOVWF TRISC
	
	BANKSEL PORTB
	MOVLW 0XFF
	MOVWF PORTB
	MOVLW 0X01
	MOVWF PORTC

SAG_KONTROL
	BTFSS PORTB,0
	GOTO SAG_KONTROL
	GOTO LED_SAG

SOL_KONTROL
	BTFSS PORTB,1
	GOTO SOL_KONTROL
	GOTO LED_SOL

LED_SAG
	RRF PORTC,F
	GOTO SAG_KONTROL

LED_SOL
	RLF PORTC,F
	GOTO SOL_KONTROL

END