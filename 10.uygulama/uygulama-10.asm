	__CONFIG H'3F31'
	LIST P=16F877A
	#INCLUDE <P16F877A.INC>
	SAYI1 EQU 0X20
	SAYI2 EQU 0X21
	TOPLAM EQU 0X22
	ORG 0X00
	GOTO ANA_METOT
	
ANA_METOT
	BANKSEL TRISB
	CLRF TRISB
	BANKSEL PORTB
	CLRF PORTB

	MOVLW B'10101010'
	MOVWF SAYI1

	MOVLW B'11110000'
	MOVWF SAYI2

	CLRW
	MOVF SAYI1,W
	ADDWF SAYI2,W
	MOVWF TOPLAM

KONTROL
	BTFSS STATUS,C
	GOTO TASMA_YOK
	GOTO TASMA_VAR

TASMA_VAR
	BSF PORTB,0
	GOTO KONTROL

TASMA_YOK
	BSF PORTB,1
	GOTO KONTROL

END