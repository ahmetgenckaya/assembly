	__CONFIG H'3F31'
	LIST P=16F877A
	#INCLUDE <P16F877A.INC>
	SAYI1 EQU 0X20
	SAYI2 EQU 0X21
	ORG 0X00
	GOTO ANA_METOT

ANA_METOT
	BANKSEL TRISB
	CLRF TRISB
	BANKSEL PORTB
	CLRF PORTB

	MOVLW D'30'
	MOVWF SAYI1

	MOVLW D'30'
	MOVWF SAYI2

KONTROL
	MOVF SAYI2,W		;W = 50
	SUBWF SAYI1,W	;W = SAYI2 - SAYI1 = 30 - 50 = -20 ; SAYILAR EÞÝT DEÐÝLDÝR.

	BTFSS STATUS,Z	;Z BÝTÝ 1 ÝSE; YANÝ SONUÇ 0 ÝSE
	GOTO DEGERLER_ESÝT_DEGÝL
	GOTO DEGERLER_ESÝT

DEGERLER_ESÝT
	BSF PORTB,0
	GOTO KONTROL

DEGERLER_ESÝT_DEGÝL
	BSF PORTB,1
	GOTO KONTROL

END

	