	__CONFIG H'3F31'
	LIST P=16F877A
	#INCLUDE <P16F877A.INC>
	SAYAC1 EQU 0X20
	SAYAC2 EQU 0X21
	ORG 0X00
	GOTO ANA_METOT
	
ANA_METOT
	BANKSEL TRISB
	MOVLW B'00000011'
	MOVWF TRISB
	MOVLW 0X00
	MOVWF TRISC

	BANKSEL PORTB	
	BSF PORTB,0
	BSF PORTB,1
	BSF PORTC,0

KONTROL
	BTFSC PORTB,0
	GOTO LED_SAG
	BTFSC PORTB,1
	GOTO LED_SOL
	GOTO KONTROL

LED_SAG
	RRF PORTC,F
	CALL GECIKME
	GOTO KONTROL

LED_SOL
	RLF PORTC,F
	CALL GECIKME
	GOTO KONTROL

GECIKME
	MOVLW 0XFA
	MOVWF SAYAC1

DONGU1
	MOVLW 0XFF
	MOVWF SAYAC2

DONGU2
	DECFSZ SAYAC2,F
	GOTO DONGU2
	DECFSZ SAYAC1,F
	GOTO DONGU1
	RETURN

END