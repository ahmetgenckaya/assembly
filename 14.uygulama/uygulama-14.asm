	__CONFIG H'3F31'
	LIST P=16F877A
	#INCLUDE <P16F877A.INC>
	SAYICI EQU 0X20
	ORG 0X00
	GOTO ANA_METOT

ANA_METOT
	BANKSEL TRISA
	MOVLW 0X06
	MOVWF ADCON1
	MOVLW 0XFF
	MOVWF TRISA
	CLRF TRISB
	BANKSEL PORTA
	MOVLW 0XFF
	MOVWF PORTA
	CLRF PORTB

	MOVLW 0X00
	MOVWF SAYICI
	
KONTROL
	BTFSC PORTA,1
	GOTO SAYICI_ARTIR
	GOTO KONTROL

SAYICI_ARTIR
	INCF SAYICI,F
	MOVF SAYICI,W
	SUBLW D'10'
	BTFSC STATUS,Z
	GOTO LED_SONDUR
	GOTO LED_YAK

LED_YAK
	MOVF SAYICI,W
	MOVWF PORTB
	GOTO KONTROL

LED_SONDUR
	CLRF PORTB
	GOTO KONTROL

END