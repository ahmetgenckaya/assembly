	LIST P=16F877A
	#INCLUDE<P16F877A.INC>
	__CONFIG H'3F31'

	SAYI EQU 0X20
	SAYI2 EQU 0X21
	SONUC EQU 0X22

	ORG 0X00
	GOTO START

START
	CLRF SONUC
	MOVLW D'10'
	MOVWF SAYI
	MOVLW D'20'
	MOVWF SAYI2
	BSF STATUS,C
DONGU
	MOVF SAYI2,W
	SUBWF SAYI,W ;20-10=10 CARRY DE���MED� 10-20=-10 CARRY SIFIR OLDU DEMEK K� TA�MA VAR
	BTFSS STATUS,C
	GOTO TASMA_VAR
	GOTO TASMA_YOK

TASMA_VAR
	MOVLW D'1'
	MOVWF SONUC

TASMA_YOK 
	MOVLW D'0'
	MOVWF SONUC

END